require cvm-reverse-proxy-client.inc

SRCREV = "v0.1.4"
