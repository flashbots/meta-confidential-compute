require cvm-reverse-proxy-server.inc

SRCREV = "v0.1.6"
