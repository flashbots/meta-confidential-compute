FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://status-all.patch"
